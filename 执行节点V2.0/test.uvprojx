# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport;.\CMSIS\inc;.\CMSIS\src;.\Fwlib;.\Listings;.\Objects;.\user;.\user\inc;.\user\src;.\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FWlib
    ./CMSIS/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DRIVER
    ./driver/src/: delay.c hx711drv.c led.c sys.c usart.c rtc_time.c 6050.c buzzer.c sht.c lora.c
  group cpu
    ./contiki-2.5/cpu/: clock.c
    ./contiki-2.5/core/: contiki.h contiki-lib.h contiki-net.h contiki-version.h
  group lib
    ./contiki-2.5/core/sys/: autostart.c
  group sys
    ./contiki-2.5/core/sys/: etimer.c process.c procinit.c timer.c
  group USER
    ./user/src/: stm32f10x_it.c contiki-main.c makefile.c
    ./user/inc/: stm32f10x_conf.h
  group example
    ./example/: printhello.c
